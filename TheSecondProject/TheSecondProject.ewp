# IAR project TheSecondProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: AbstractHardware\Registers\STM32F411; AbstractHardware\Registers\STM32F411\FieldValues; AbstractHardware\Registers; Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MyNewProject.srec
  ILINK.IlinkOutputFile: MyNewProject.out
  ILINK.IlinkIcfFile: D:\POIP\Ксения\POIP\MyNewProject\MyNewProject.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp
