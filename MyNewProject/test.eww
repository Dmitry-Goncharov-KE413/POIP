<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\myProject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Project_for_timers\Timers.ewp</path>
    </project>
    <batchBuild />
</workspace>
