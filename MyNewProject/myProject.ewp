# IAR project myProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: AbstractHardware\Registers\STM32F411; AbstractHardware\Registers\STM32F411\FieldValues; AbstractHardware\Registers; Common; Hardware; Hardware\Pin; Components; Components\Button; Components\LED; Modes; Modes\AllMode; Modes\ChessMode; Modes\TreeMode; Modes\Garland; D:\POIP\POIP\MyNewProject\Modes\SlideMode
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: myProject.srec
  ILINK.IlinkOutputFile: myProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp
  group Components/Button
    Components/Button/: Button.cpp IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: Led.cpp Led.h
  group Hardware/Pin
    Hardware/Pin/: ipin.h pin.h pinconfig.h
  group Modes
    Modes/Garland/: Garland.h IMode.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp
  group Modes/Slide
    Modes/SlideMode/: SlideMode.cpp
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp
